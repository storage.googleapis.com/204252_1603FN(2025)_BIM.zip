Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: e894146a-4833-4a84-92aa-b003607abd5d, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 1603FN(2025).ifc
Time: 2025-05-20T22:40:28
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Circle Head - Project Datum (2)
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Circle Head - Project Datum; Type: Circle Head - Project Datum; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle : Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Identity Data(Type) - Type Name: Circle Head - Project Datum
Other(Type) - Category: Levels; Family Name: Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Level 0 | Level 0 | 0
Level 1 | Level 1 | 4000

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SINK
Name
InPort_325205_1
InPort_325205_2

# IfcFlowController: 1603FN(2025):1603FN Washbasin faucet, 1603FN(2025):1603FN Washbasin faucet:325205
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - General - Author: BIMStone; BIMObjectName: 1603FN(2025); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_10; Uniclass2015Description: Bath thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_10; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; Noise Class: I (ISO 3822); NRF Number: 1401483; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1603FN; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1603FN
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Rapid installation system; Aerator: PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste;Without draw-rod opening; Flow Rate At 300kPa With Flow Controller: 0.08 dm3/s; Installation Type: Deck mounted; Lever Handle: Hot/Cold symbols;Single operating lever/handle; Max. Hot Water Supply: 70 C; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Spout Projection: 112 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 149.489 mm; NominalHeight: 145.504 mm; NominalWidth: 47.1582 mm
Type - Identity Data - 3D View: https://static.oras.com/3D/1603FN; Catalog Drawing URL: http://static.oras.com/catdrw/1603FN; Category B2C: Washbasin; Dimension Drawing URL: http://static.oras.com/dimdrw/1603FN; FDV Document URL: http://www.oras.com/datasheet/1603FN/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1603FN; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1603FN; Interactive AR View URL: https://static.oras.com/AR/1603FN; Long Marketing: Timeless choice for every modern bathroom. Introducing the universal Oras Linea washbasin faucet. With a chrome finish and single operating lever, this deck-mounted faucet adds a modern touch to any washbasin. The fixed spout with hot and cold symbols are made for effortless use, while the rapid installation system ensures quick and easy installation. It comes with a classic design and very good price performance. Choose the Linea line for daily enjoyment in everyday use.; Manufacturer: Oras; Market: International;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1603FN; Model: 1603FN Washbasin faucet; Name_en: 1603FN Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1603FN; Product Family: Oras Linea XL; Product Image URL: http://static.oras.com/image/1603FN; Product URL: http://static.oras.com/1603FN; Spare-Part Information URL: http://static.oras.com/sp/1603FN; Technical DataSheet URL: http://www.oras.com/datasheet/1603FN/en; Type Name: 1603FN Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1603FN(2025); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1603FN; Name: 1603FN Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x150x145 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Material: <Unnamed>, Brass
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level 0; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Dimensions - Area: 0.0367619 m2; Volume: 0.00103046 m3
Identity Data - Mark: 3
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1603FN(2025); Family and Type: 1603FN(2025): 1603FN Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1603FN Washbasin faucet; Type Id: 325189; WarrantyStartDate: n/a
